# Keil uVision project ISP_SPI.uvprojx, settings and files
target ISP_SPI (6190000::V6.19::ARMCLANG)
  device: M4521SE6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x1FFFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: M4521_ISP_SPI
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 v6Lang=3 v6LangP=3 wLevel=3
  c define: TARGET_M4521
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\M4521\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M4521_isp.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M4521/Source/: system_M4521.c
    ../../../../Library/Device/Nuvoton/M4521/Source/ARM/: startup_M4521_isp.s
  group User
    ../: main.c fmc_user.c isp_user.c targetdev.c spi_transfer.c

# IAR project fmc_ap_main.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M451AE series Nuvoton M451AE series (M451AE,M452AE,M453AE,M451MAE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M4521\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: fmc_ap_main.bin
  ILINK.IlinkOutputFile: APROM_code.out
  ILINK.IlinkIcfFile: fmc_ap_main.icf
  ILINK.IlinkExtraOptions: --image_input Release\Exe\fmc_ld_iap.bin,loaderImage1Base,.bin_image,4; --image_input dummy.bin,loaderImage1Limit,.bin_image,4
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M4521/Source/IAR/: startup_M4521.s
    ../../../../Library/Device/Nuvoton/M4521/Source/: system_M4521.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c
  group User
    ../: APROM_main.c

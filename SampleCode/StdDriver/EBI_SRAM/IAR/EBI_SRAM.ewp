# IAR project EBI_SRAM.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M451AE series Nuvoton M451AE series (M451AE,M452AE,M453AE,M451MAE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M4521\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EBI_SRAM.bin
  ILINK.IlinkOutputFile: EBI_SRAMT.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M4521/Source/IAR/: startup_M4521.s
    ../../../../Library/Device/Nuvoton/M4521/Source/: system_M4521.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c ebi.c pdma.c retarget.c sys.c uart.c
  group User
    ../: ebi_sram.c main.c

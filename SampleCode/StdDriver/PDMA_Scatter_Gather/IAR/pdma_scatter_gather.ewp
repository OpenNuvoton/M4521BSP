# IAR project pdma_scatter_gather.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M451AE series Nuvoton M451AE series (M451AE,M452AE,M453AE,M451MAE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M4521\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: pdma_scatter_gather.bin
  ILINK.IlinkOutputFile: pdma_scatter_gather.out
  ILINK.IlinkIcfFile: pdma_scatter_gather.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M4521/Source/IAR/: startup_M4521.s
    ../../../../Library/Device/Nuvoton/M4521/Source/: system_M4521.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c pdma.c retarget.c sys.c uart.c
  group User
    ../: main.c

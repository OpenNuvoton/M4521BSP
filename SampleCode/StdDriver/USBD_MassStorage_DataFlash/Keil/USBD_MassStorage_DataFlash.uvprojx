# Keil uVision project USBD_MassStorage_DataFlash.uvprojx, settings and files
target USBD_MassStorage_DataFlash (6120000::V6.12::.\ARMCLANG)
  device: M4521RE6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: USBD_MassStorage_DataFlash
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\Device\Nuvoton\M4521\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M4521.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M4521/Source/: system_M4521.c
    ../../../../Library/Device/Nuvoton/M4521/Source/ARM/: startup_M4521.s
  group User
    ../: main.c DataFlashProg.c descriptors.c MassStorage.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c clk.c fmc.c sys.c usbd.c

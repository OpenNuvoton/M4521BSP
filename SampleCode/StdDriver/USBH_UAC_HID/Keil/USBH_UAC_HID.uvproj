# Keil uVision project USBH_UAC_HID.uvproj, settings and files
target USBH_UAC_HID (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: M4521RE6AE Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: usbh_uac_hid
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M4521\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\UsbHostLib\Include;..\..\..\..\ThirdParty\FATFS\src
  asm define: Stack_Size=0x800, Heap_Size=0x100
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M4521.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M4521/Source/: system_M4521.c
    ../../../../Library/Device/Nuvoton/M4521/Source/ARM/: startup_M4521.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c
  group USBH_Core_Lib
    ../../../../Library/UsbHostLib/Source/Core/: usbh_core.c usbh_debug.c usbh_hub.c usbh_ohci.c usbh_support.c
  group USBH_UAC_Lib
    ../../../../Library/UsbHostLib/SOURCE/AudioClass/: uac_core.c uac_driver.c uac_parser.c
  group USBH_HID_Lib
    ../../../../Library/UsbHostLib/SOURCE/Hid/: hid_core.c hid_driver.c
